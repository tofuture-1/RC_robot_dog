# Keil uVision project RC_RobotDog_Rebuild20260605.uvprojx, settings and files
target RC_RobotDog_Rebuild20260605 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RC_RobotDog_Rebuild20260605 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Development_Layer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Development_Layer
    ../Development_Layer/Task/CallBack_Task/: callback_task.cpp callback_task.h
    ../Development_Layer/Function_Class/: foot_control.cpp foot_control.h
    ../Development_Layer/Function_Class/Class_RobotDog/: robotdog_class.cpp robotdog_class.h
    ../Development_Layer/Robot_Control/Foot_Control/: foot_control.cpp foot_control.h
    ../Development_Layer/Robot_Control/Controller/: PID.cpp PID.h
    ../Development_Layer/External_Device/Motor/: Motor_DM.cpp Motor_DM.h
    ../Development_Layer/Driver/CAN/: drv_can.cpp drv_can.h
    ../Development_Layer/Driver/Math/: drv_math.cpp drv_math.h
    ../Development_Layer/Driver/Tim/: drv_tim.cpp drv_tim.h
    ../Development_Layer/Driver/UART/: drv_uart.cpp drv_uart.h
software components: CMSIS:CORE 4.3.0
